options:
  parameters:
    comment: |-
      Este tipo de modulación es
      la que se usa en aplicaciones
      para entretenimiento de 
      Radio y TV
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Receptor WBFM
  states: {}

blocks:
- name: filtro
  id: variable_qtgui_range
  parameters:
    label: Filtro
    start: 1e3
    step: '10000'
    stop: 250e3
    value: 144e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frecuencia
    start: 90e6
    step: '100000'
    stop: 120e6
    value: 120e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Frecuencia de
      muestreo
      inicial
    value: 2e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: Demodulo la señal
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Reproduzco el audio
    samp_rate: '48000'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    comment: |-
      Visualizo la señal
      adquirida
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    comment: |-
      Visualizo la señal
      filtrada
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0_0
  id: blocks_throttle
  parameters:
    comment: |-
      Visualizo la señal
      demodulada
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Filtro para quedarme
      con la desviación 
      máxima admitida en 
      FM (75KHz)
    cutoff_freq: filtro
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_RECTANGULAR
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    comment: Adquiero la señal de entrada
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: FFT Señal Adquirida
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: FFT Señal Filtrada
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: FFT Señal Demodulada
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Adapto la señal demodulada a la frecuencia 
      de audio de 48KHz
    decim: '2000'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: entrada
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: filtrada
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: entrada
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: filtrada
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_wfm_rcv_0, '0', virtual_sink_0, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_1_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_1_0_0, '0', qtgui_freq_sink_x_2, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', blocks_throttle_1, '0']
- [virtual_source_1_0, '0', blocks_throttle_1_0, '0']
- [virtual_source_1_0_0, '0', blocks_throttle_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
