options:
  parameters:
    comment: |-
      Emisor Wide Band 
      Frequency Modulation
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Emisor WBFM
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    comment: |-
      Frecuencia de 
      la portadora
    value: 120e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Frecuencia de 
      muestreo inicial
    value: 2e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '10'
    stop: '10'
    value: '2'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '2000000'
    comment: |-
      Audio Rate = frecuencia de entrada
      Quadrature Rate = frecuencia de salida
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '2000000'
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Amplifico un poco la señal 
      que mando al HackRF
    const: vol
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Volumen de 
      entrada del audio
    const: '10'
    type: float
  states: {}
- name: blocks_throttle_2
  id: blocks_throttle
  parameters:
    comment: |-
      Visualizo la señal final
      a enviar con nuestro 
      equipo SDR
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_2_0
  id: blocks_throttle
  parameters:
    comment: |-
      Visualizo la señal
      de audio
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Puedo utilizar un fichero de 
      audio WAV o un micrófono 
      que esté conectado al PC
    file: C:\Users\Jesus\Desktop\SDR\Programas Introduccion a SDR con GNU Radio\Transmisor AM\TRAANSAMAM.wav
    repeat: 'True'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Elimino las frecuencias
      altas para emitir la señal 
      más limpia posible.
    cutoff_freq: '100000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    comment: Genero la señal en el equipo SDR
    freq0: freq
    gain0: '50'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    name: Audio FFT
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: FFT de la Señal a Enviar
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Subo la frecuencia de 
      muestreo de los 48KHz 
      del audio a los 2MHz que
      necesito de entrada en 
      el HackRF
    decim: '48'
    interp: '2000'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: salida
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: salida
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0_0, '0']
- [blocks_throttle_2, '0', qtgui_freq_sink_x_1, '0']
- [blocks_throttle_2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [virtual_source_0, '0', blocks_throttle_2, '0']
- [virtual_source_0_0, '0', blocks_throttle_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
