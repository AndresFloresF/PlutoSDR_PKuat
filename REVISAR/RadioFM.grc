options:
  parameters:
    author: andresflores
    generate_options: qt_gui
    id: RadioFM
    output_language: python
    title: FM RADIO
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '90000000'
    step: '100000'
    stop: '110000000'
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '520833'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '2'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Señal Recibida"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '103000000'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', analog_fm_demod_cf_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
