options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '30719998'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/andresflores/ADALM-Pluto-File-Transfer/receivedfile.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: ''
    file: /home/andresflores/ADALM-Pluto-File-Transfer/transmissionfile.txt
    repeat: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
