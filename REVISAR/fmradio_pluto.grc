options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '2800000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: default
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM station
    type: eng_float
    value: 99.3e6
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    frequency: '99300000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: '7'
    gain: '1'
    samp_rate: sample_rate / decimation
    type: fir_filter_ccf
    width: '44100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: fm_station
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
